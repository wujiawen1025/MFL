# Keil uVision project GD32F303_Boot.uvprojx, settings and files
target GD32F30X_HD_Boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Boot_GD32F303_256K +hex
  AfterMake: ".\..\..\烧写文件_带Boot\BatTools\mergeGD32F303_256K_KeilUser.bat"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,GD32F30X
  c include: ..\SourceFile\BSP\Firmware\CMSIS;..\SourceFile\BSP\Firmware\CMSIS\GD\GD32F30x\Include;..\SourceFile\BSP\Firmware\GD32F30x_standard_peripheral\Include;..\SourceFile\UserApp;..\SourceFile\BSP\bsp_drv\inc;..\SourceFile\EasySoftFrame\inc;..\SourceFile\UserApp\UserCfg;..\SourceFile\EasySoftFrame;..\SourceFile\UserApp\BootLoader\IAP\inc;..\SourceFile\UserApp\BootLoader\CDP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group GD32F30x_CPU
    ../SourceFile/BSP/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group GD32F30x_PerihpLib
    ../SourceFile/BSP/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CMSIS
    ../SourceFile/BSP/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group BSP
    ../SourceFile/BSP/bsp_drv/src/: bsp.c bsp_systicker.c bsp_uart.c bsp_gpio.c bsp_pwmtmr.c bsp_watchdog.c bsp_flash.c bsp_feep.c
  group ESF
    ../SourceFile/EasySoftFrame/src/: ESF.c ESF_CPU.c ESF_Evt.c ESF_Mem.c ESF_Tmr.c
    ../SourceFile/EasySoftFrame/: CommonLib.c
  group UserCfg
    ../SourceFile/UserApp/UserCfg/: GlobalCfg.h ESF_Cfg.h bsp_Cfg.h
  group UserAPP
    ../SourceFile/UserApp/: main.c System.c
  group BootLoader
    ../SourceFile/UserApp/BootLoader/IAP/src/: IAP.c
    ../SourceFile/UserApp/BootLoader/CDP/src/: CDP.c CDP_Xxx_Ctrl.c SideBoard_806.c
